// ServoControl.ino - SG90 on a 50 Hz PWM signal generated by the ESP32 LEDC peripheral (no extra library).
#define SERVO_LEDC_CHANNEL  2      // channel 2 uses a different timer than the motor channels 0/1
#define SERVO_PWM_BITS      14     // 20 ms / 16384 = 1.2 us resolution
#define SERVO_PERIOD_US     20000

static float s_servoAngle = SERVO_NEUTRAL_ANGLE;
static bool s_servoReady = false;

static uint32_t servoAngleToDuty(float deg) {
  float us = SERVO_MIN_US + (SERVO_MAX_US - SERVO_MIN_US) * deg / 180.0f;
  return (uint32_t)(us * (1UL << SERVO_PWM_BITS) / SERVO_PERIOD_US + 0.5f);
}

bool servoInit() {
  s_servoReady = ledcAttachChannel(PIN_SERVO, 50, SERVO_PWM_BITS, SERVO_LEDC_CHANNEL);
  if (!s_servoReady) {
    LOGE("SERVO", "PWM setup FAILED on GPIO%d", PIN_SERVO);
    return false;
  }
  ledcWrite(PIN_SERVO, servoAngleToDuty(SERVO_NEUTRAL_ANGLE));
  LOGI("SERVO", "SG90 ready on GPIO%d: neutral %d deg, allowed %d..%d deg, pulse %d..%d us", PIN_SERVO, SERVO_NEUTRAL_ANGLE,
       SERVO_MIN_ANGLE, SERVO_MAX_ANGLE, SERVO_MIN_US, SERVO_MAX_US);
  return true;
}

// Returns false (and changes nothing) if the angle is not a finite number inside the allowed range.
bool servoSetAngle(float deg) {
  if (!s_servoReady) {
    LOGE("SERVO", "command ignored: servo PWM is not initialised");
    return false;
  }
  if (!isfinite(deg) || deg < SERVO_MIN_ANGLE || deg > SERVO_MAX_ANGLE) {
    LOGW("SERVO", "invalid angle %.1f rejected (allowed %d..%d)", deg, SERVO_MIN_ANGLE, SERVO_MAX_ANGLE);
    return false;
  }
  uint32_t duty = servoAngleToDuty(deg);
  ledcWrite(PIN_SERVO, duty);
  LOGD("SERVO", "requested %.1f deg -> applied %.1f deg (duty %lu)", deg, deg, (unsigned long)duty);
  s_servoAngle = deg;
  return true;
}

void servoNeutral() {
  servoSetAngle(SERVO_NEUTRAL_ANGLE);
  LOGI("SERVO", "returned to neutral (%d deg)", SERVO_NEUTRAL_ANGLE);
}

float servoGetAngle() { return s_servoAngle; }
